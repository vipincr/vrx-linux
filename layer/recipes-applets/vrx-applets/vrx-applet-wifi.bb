SUMMARY = "vrx applet: Wi-Fi (scan, join, forget, over connman)"
VRX_APPLET = "wifi"
require vrx-applet.inc
