SUMMARY = "vrx applet: Device Link (pair a phone over Bluetooth)"
VRX_APPLET = "devicelink"
require vrx-applet.inc
