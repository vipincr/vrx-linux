SUMMARY = "vrx applet: Shell (the status strip and the quick drawer)"
VRX_APPLET = "shell"
require vrx-applet.inc
