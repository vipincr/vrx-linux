SUMMARY = "vrx applet: Licences (the image's license manifest)"
VRX_APPLET = "docs"
require vrx-applet.inc
