SUMMARY = "vrx applet: USB (share files with a connected computer)"
VRX_APPLET = "usbport"
require vrx-applet.inc
