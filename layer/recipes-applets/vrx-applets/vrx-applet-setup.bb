SUMMARY = "vrx applet: Setup (the first-boot walk)"
VRX_APPLET = "setup"
require vrx-applet.inc
