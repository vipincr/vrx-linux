SUMMARY = "vrx applet: the vrx clock"
VRX_APPLET = "clock"
require vrx-applet.inc
