SUMMARY = "vrx applet: USB (share files with a connected computer)"
VRX_APPLET = "usb"
require vrx-applet.inc
