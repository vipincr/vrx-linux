SUMMARY = "vrx applet: the vrx home screen"
VRX_APPLET = "launcher"
require vrx-applet.inc
