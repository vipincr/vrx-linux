SUMMARY = "vrx applet: vrx settings"
VRX_APPLET = "settings"
require vrx-applet.inc
