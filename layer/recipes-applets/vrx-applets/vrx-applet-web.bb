SUMMARY = "vrx applet: Web requests (fetch a URL, see the response)"
VRX_APPLET = "web"
require vrx-applet.inc
