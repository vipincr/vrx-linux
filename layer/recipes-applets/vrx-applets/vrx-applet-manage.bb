SUMMARY = "vrx applet: Manage (serve the management page to a browser)"
VRX_APPLET = "manage"
require vrx-applet.inc
